# Keil uVision project registor.uvprojx, settings and files
target dev (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f1_register
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\System;..\Drivers\Inc;..\Drivers\Src;..\Modules\ring_buffer;..\Modules\variadic_uart;..\Core;..\Modules\ds3231
  asm include: ..\driver\inc;..\driver\src;..\driver\ring_buffer;..\driver\variadic_uart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../Core/: main.c
  group system
    ../System/: peripherals.h stm32system.h stm32util.h
  group src
    ../Drivers/src/: rcc.c systick.c afio.c gpio.c exti.c tim.c adc.c uart.c spi.c iic.c
  group inc
    ../Drivers/inc/: rcc.h systick.h afio.h gpio.h exti.h tim.h adc.h uart.h spi.h iic.h
  group ring_buffer
    ../Modules/ring_buffer/: ring_buffer.c ring_buffer.h
  group variadic_uart
    ../Modules/variadic_uart/: uart_vprintf.c uart_vprintf.h
  group ds3231
    ../Modules/ds3231/: ds3231.c ds3231.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
